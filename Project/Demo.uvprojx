# Keil uVision project Demo.uvprojx, settings and files
target stm32f407ve (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\APP\inc;..\Drivers\BSP\inc;..\Drivers\CMSIS\inc;..\Drivers\SYSTEM\inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Middlewares\Third_Party\FreeRTOS\include;..\Middlewares\Third_Party\FreeRTOS\portable\MemMang;..\Middlewares\Third_Party\FreeRTOS\portable\RVDS\ARM_CM4F;..\MiddleWares\Third_Party\WIZnet\inc;..\MiddleWares\Third_Party\MQTT\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/src/: main.c stm32f4xx_it.c utask.c
  group BSP
    ../Drivers/BSP/src/: led.c spi.c network.c time.c
  group CORE
    ../Drivers/CMSIS/src/: system_stm32f4xx.c
  group Startup
    ../Drivers/CMSIS/startup/: startup_stm32f40_41xxx.s
  group FWLIB
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../Drivers/SYSTEM/src/: delay.c sys.c usart.c
  group FreeRTOS_CORE
    ../Middlewares/Third_Party/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORT
    ../Middlewares/Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Ethernet
    ../MiddleWares/Third_Party/WIZnet/src/: socket.c w5500.c wizchip_conf.c
  group Internet
    ../MiddleWares/Third_Party/WIZnet/src/: dhcp.c dns.c
  group MQTT
    ../MiddleWares/Third_Party/MQTT/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group ReadMe
    ../Doc/: ReadMe.txt
